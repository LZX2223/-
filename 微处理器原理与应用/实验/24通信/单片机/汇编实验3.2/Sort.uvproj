# Keil uVision project Sort.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: Sort +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/Epan/Study/微处理器原理与应用/单片机实验/汇编实验3.2/: STARTUP.A51
    ./: Sort.c
