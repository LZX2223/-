# Keil uVision project DHT11.uvproj, settings and files
target DHT11 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DHT11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source
  group STARTUP
    ./: STARTUP.A51
  group USER
    ./source/: LCD1602.c MIAN.C DHT11.C DHT11.H LCD1602.h typedef.h
