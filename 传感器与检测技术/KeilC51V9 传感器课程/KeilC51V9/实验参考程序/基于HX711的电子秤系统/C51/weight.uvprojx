# Keil uVision project weight.uvprojx, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: weight +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ./: STARTUP.A51
    ../src/: delay.c HX711.c main.c 1602.c uart.c
